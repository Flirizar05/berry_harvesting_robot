Commit message: Checkpoint before mode1 gripper flow changes

File: harvesting_robot/urdf/gen3.urdf (robot description, URDF)
Before this commit: robot gen3, 10 links, 9 joints
Joints:
- joint tool_frame_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0.2 rpy=0 0 0
